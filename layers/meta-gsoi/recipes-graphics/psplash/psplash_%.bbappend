# GSOI: sostituisce il logo di psplash con lo splash GSOI.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# psplash rigenera il logo compilato ("default") da questo PNG.
SPLASH_IMAGES = "file://gsoi-splash.png;outsuffix=default"
